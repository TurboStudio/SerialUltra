# Keil uVision project ultrasonic.uvproj, settings and files
target ultrasonic (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: ultrasonic +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Inc;.\Src
  group Startup
    ./: STARTUP.A51
  group Inc
    ./Inc/: uart.h cmd.h main.h adc.h ultrasonic.h timer.h STC8Gxx.h
  group Src
    ./Src/: adc.c cmd.c main.c timer.c uart.c ultrasonic.c
